# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS-Plus-FAT-SL\api;..\FreeRTOS-Plus-FAT-SL\config;..\FreeRTOS-Plus-FAT-SL\fat_sl\common;..\FreeRTOS-Plus-FAT-SL\psp\include;..\FreeRTOS-Plus-FAT-SL\version;..\FreeRTOS-Plus-CLI;..\HARDWARE\SDIO;..\APP\UART_COMMAND;..\HARDWARE\TIMER;..\HARDWARE\DS18B20;..\APP\DS18B20;..\HARDWARE\SENSE_485;..\APP\SENSE_MODBUS;..\APP\EEPROM_SAVE;..\HARDWARE\at24cxx;..\HARDWARE\SIM7600CE;..\APP\SIM7600CE_TCP;..\APP\COMMUNICATION_TCP;..\APP\DATA_REPORT;..\HARDWARE\SWITCH_IO;..\APP\SWITCH;..\HARDWARE\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/SENSE_485/: sense_485.c
    ../HARDWARE/at24cxx/: at24cxx.c
    ../HARDWARE/SIM7600CE/: sim7600ce.c
    ../HARDWARE/SWITCH_IO/: switch_io.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../: README.TXT
  group FreeRTOS_FAT_SL
    ../FreeRTOS-Plus-FAT-SL/fat_sl/common/: dir.c drv.c f_lock.c fat.c file.c util.c util_sfn.c volume.c
    ../FreeRTOS-Plus-FAT-SL/psp/target/rtc/: psp_rtc.c
  group FreeRTOS_CL
    ../FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group APP
    ../APP/FILE/: File-Releated-CLI-commands.c File-system-demo.c Sample-CLI-commands.c
    ../APP/UART_COMMAND/: UartCommondServe.c
    ../APP/DS18B20/: DS18B20_GetTemperature.c
    ../APP/SENSE_MODBUS/: sense_modbus.c
    ../APP/EEPROM_SAVE/: eeprom_save.c
    ../APP/SIM7600CE_TCP/: sim7600ce_tcp.c
    ../APP/COMMUNICATION_TCP/: communication_tcp.c
    ../APP/DATA_REPORT/: data_report.c
    ../APP/SWITCH/: Switch_Task.c
  group Media-drv
    ../FreeRTOS-Plus-FAT-SL/media-drv/sd/: sddrv_f.c
  group DataCheck
    ./: Check_CRC.c
